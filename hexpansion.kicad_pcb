# Repository ArcaneNibble/hexpansion-headphones

File README.md:

# EMFCamp Hexpansion -- headphone jack

ES8388 headphone codec chip

## KiCad design hexpansion.kicad_pcb

Parts:
C1, C2, C4, C6, C8, C10: 10 uF; C_0603_1608Metric; LCSC C19702
C3, C5, C7, C9, C11, C12, C21, C22: 0.1 uF; C_0402_1005Metric; LCSC C1525
C13, C14: 47 uF; C_1206_3216Metric; LCSC C96123
C15, C16, C17, C18, C19, C20: 1 uF; C_1206_3216Metric; LCSC C1848
H1, H2: MountingHole_Pad; MountingHole_2.2mm_M2_Pad_Via
J1: Hexpansion-Connector; hexpansion-edge-connector
J2, J3, J4: AudioJack4; Jack_3.5mm_KoreanHropartsElec_PJ-320D-4A_Horizontal; LCSC C431535
JP1: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP2: ADDR_LSB0; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
R1, R2, R3, R4: 10; R_0603_1608Metric; LCSC C22859
R5, R6, R7, R8: 10k; R_0402_1005Metric; LCSC C25744
TP1: MIC_R; TestPoint_Pad_2.0x2.0mm
TP2: SCL; TestPoint_Pad_2.0x2.0mm
TP3: SDA; TestPoint_Pad_2.0x2.0mm
TP4: ASDOUT; TestPoint_Pad_1.0x1.0mm
TP5: DSDIN; TestPoint_Pad_1.0x1.0mm
U1: ES8388; QFN-28-1EP_4x4mm_P0.45mm_EP2.6x2.6mm; LCSC C365736
U2, U3: 74LVC1G125; SOT-23-5; LCSC C23654

Connections:
+3.3V: C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C21.1, C22.1, J1.15 (3V3), J1.16 (3V3), JP2.3 (B), R5.1, R6.1, R7.1, U1.2 (DVDD), U1.3 (PVDD), U1.16 (HPVDD), U1.17 (AVDD), U2.5 (VCC), U3.5 (VCC)
/ASDOUT: TP4.1, U1.8 (ASDOUT), U2.2
/DSDIN: TP5.1, U1.6 (DSDIN), U3.4
/HEXP_DET: J1.6 (HEXP_DET), JP1.1 (A)
/HP_L: J2.T, R1.2
/HP_R: J2.R1, R2.2
/I2S_DATA_SHARED: J1.19 (HS_I), U2.4, U3.2
/LINEIN_L: C19.1, J4.T
/LINEIN_R: C20.1, J4.R1
/LINEOUT_L: J3.T, R4.2
/LINEOUT_R: J3.R1, R3.2
/LRCLK: J1.18 (HS_H), U1.7 (LRCK)
/MCLK: J1.12 (HS_F), U1.1 (MCLK)
/MIC_L: C17.1, J2.S
/MIC_R: C18.1, TP1.1
/SCL: J1.5 (SCL), R6.2, TP2.1, U1.28 (CCLK)
/SCLK: J1.13 (HS_G), U1.5 (SCLK)
/SDA: J1.4 (SDA), R5.2, TP3.1, U1.27 (CDATA)
/~MIC_EN: J1.2 (LS_A), R7.2, U2.1
/~OUT_EN: J1.3 (LS_B), R8.1, U3.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C21.2, C22.2, H1.1, H2.1, J1.1 (GND), J1.10 (GND), J1.11 (GND), J1.14 (GND), J1.17 (GND), J1.20 (GND), J2.R2, J3.R2, J3.S, J4.R2, J4.S, JP1.2 (B), JP2.1 (A), R8.2, U1.4 (DGND), U1.13 (HPGND), U1.18 (AGND), U1.29 (PAD), U2.3 (GND), U3.3 (GND)
unnamed: C13.2, R1.1
unnamed: C14.2, R2.1
unnamed: C15.2, R4.1
unnamed: C16.2, R3.1
unnamed: JP2.2 (C), U1.26 (CE)
unnamed: C2.1, C3.1, U1.19 (ADCVREF)
unnamed: C17.2, U1.24 (LIN1)
unnamed: C19.2, U1.22 (LIN2)
unnamed: C13.1, U1.12 (LOUT1)
unnamed: C15.1, U1.15 (LOUT2)
unnamed: C18.2, U1.23 (RIN1)
unnamed: C20.2, U1.21 (RIN2)
unnamed: C14.1, U1.11 (ROUT1)
unnamed: C16.1, U1.14 (ROUT2)
unnamed: C4.1, C5.1, U1.20 (VMID)
unnamed: C1.1, U1.10 (VREF)

Notes on the sheet:
PVDD
AVDD
WARN: the Korean Hroparts and ShenZhen ShouHan dimensions are *not* equal, **BUT** they appear close enough to use the same footprint
TODO do we want higher quality filtering?
lol the cheapest jack is a TRRS
HPVDD
xxx verify this is a MCLK capable pin???
the pin ordering is logically numbered differently in the Korean Hroparts vs ShenZhen ShouHan datasheets the ShenZhen ShouHan datasheet says "插头第1-4节分别对应功能是：左 右 接地 唛" which does not make mechanical sense at all what is drawn here is consistent with most other examples of "PJ-320D" parts
DVDD

Board: 2 copper layers, 38.8 x 38.0 mm, 46 parts (6 on the bottom side), 37 nets.

## Commit log

2024-04-03 Initial import
2024-04-03 re-save in kicad 8
2024-04-03 extract out hexpansion parts to custom library
2024-04-04 add codec symbol
2024-04-04 rough sch
2024-04-04 footprint for codec
2024-04-04 rough everything
2024-04-04 rough route
    purposely ignore extra gnd
2024-04-04 tweaks
2024-04-04 more small tweaks
2024-04-23 metadata
2024-04-23 doodles, fab layer cleanup
2024-04-23 generate fab outputs
2024-04-24 Add rev A schematic as PDF
2024-09-04 Add README
